# Keil uVision project stm32-test.uvprojx, settings and files
target Template (6210000::V6.21::ARMCLANG)
  device: STM32F103C6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00002800) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32-test +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  AfterMake: fromelf.exe --text -a -c -o "$L@L.dis" "#L"
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103x6
  c include: ..\..\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\..\Drivers\STM32F1xx_HAL_Driver\Inc;..\..\Drivers\CMSIS\Include;..\..\Users;..\..\Drivers\CMSIS\CoreValidation\Include;..\..\Drivers\CMSIS\CoreValidation\Source\Config;..\..\Drivers\CMSIS\Core\Include;..\..\Drivers\CMSIS\Core\Include\m-profile
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group Startup
    ../../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xb.s
  group User
    ../../Users/: main.c sys.c test-ctype.c test-math.c
  group CMSIS
    ../../Drivers/CMSIS/CoreValidation/Source/: CV_CoreInstr.c CV_CoreFunc.c CV_Report.c
